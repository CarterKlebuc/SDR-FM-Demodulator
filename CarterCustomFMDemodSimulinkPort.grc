options:
  parameters:
    generate_options: qt_gui
    id: CarterCustomFMDemodSimulinkPort
    output_language: python
    title: Hello
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: 97.9e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate / (10 * 5)
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_magphase_1_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: (samp_rate/10)/(2 * 3.14 * 75e3)
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 90e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate * 2
    type: fir_filter_ccf
    width: 30e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 21e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate / 10
    type: fir_filter_fff
    width: 3e3
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_frequency
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_magphase_1_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_1_0, '1', blocks_multiply_const_xx_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [blocks_multiply_const_xx_0, '0', low_pass_filter_1_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_magphase_1_0, '0']
- [low_pass_filter_1_0, '0', blocks_delay_0_0, '0']
- [low_pass_filter_1_0, '0', blocks_multiply_xx_0_0, '0']
- [low_pass_filter_1_0_0, '0', analog_fm_deemph_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_1_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
